# Keil uVision project Nuvoton Bootloader.uvprojx, settings and files
target Nuvoton Bootloader (6180000::V6.18::ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: Nuvoton Bootloader +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;D:\Software Tools\Keil\Nuvoton\Library\CMSIS\Include;D:\Software Tools\Keil\Nuvoton\Library\Device\Nuvoton\M251\Include;D:\Software Tools\Keil\Nuvoton\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: D:\Software Tools\Keil\Nuvoton\Library\Device\Nuvoton\M251\Source\ARM\LDROM.sct
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../Keil/: startup_M251_user.s
    D:/Software Tools/Keil/Nuvoton/Library/Device/Nuvoton/M251/Source/: system_M251.c
  group User
    ../: descriptors.c main.c hid_transfer.c fmc_user.c isp_user.c targetdev.c usbd_user.c
    ./: Degiskenler.h
software components: CMSIS:CORE 5.0.1
